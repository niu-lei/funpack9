# Keil uVision project Project_ab.uvprojx, settings and files
target IKS01A2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L4xx-Nucleo-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\IKS01A2\Objects\@L.bin !L
  c flags: OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,USE_IKS01A2,ARM_MATH_CM4,USE_NUCLEO
  c misc: --C99
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\Drivers\BSP\IKS01A2;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components/IKS01A2
    ./IKS01A2/Objects/: hts221.o hts221_reg.o lps22hb.o lps22hb_reg.o lsm6dsl.o lsm6dsl_reg.o lsm303agr.o lsm303agr_reg.o
  group Drivers/BSP/Components/IKS01A3
    ./IKS01A3/Objects/: hts221.o hts221_reg.o lis2dw12.o lis2dw12_reg.o lis2mdl.o lis2mdl_reg.o lps22hh.o lps22hh_reg.o lsm6dso.o lsm6dso_reg.o stts751.o stts751_reg.o
  group Drivers/BSP/STM32L4xx_Nucleo/IKS01A2
    ./IKS01A2/Objects/: stm32l4xx_nucleo.o
  group Drivers/BSP/STM32L4xx_Nucleo/IKS01A3
    ./IKS01A3/Objects/: stm32l4xx_nucleo.o
  group Drivers/BSP/IKS01A2
    ./IKS01A2/Objects/: iks01a2_env_sensors.o iks01a2_env_sensors_ex.o iks01a2_motion_sensors.o iks01a2_motion_sensors_ex.o
  group Drivers/BSP/IKS01A3
    ./IKS01A3/Objects/: iks01a3_env_sensors.o iks01a3_env_sensors_ex.o iks01a3_motion_sensors.o iks01a3_motion_sensors_ex.o
  group Drivers/CMSIS/IKS01A2
    ./IKS01A2/Objects/: system_stm32l4xx.o
  group Drivers/CMSIS/IKS01A3
    ./IKS01A3/Objects/: system_stm32l4xx.o
  group Drivers/STM32L4xx_HAL_Driver/IKS01A2
    ./IKS01A2/Objects/: stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gpio.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_msp.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o
  group Drivers/STM32L4xx_HAL_Driver/IKS01A3
    ./IKS01A3/Objects/: stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gpio.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_msp.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o
  group Example/AlgoBuilder/IKS01A2
    ./IKS01A2/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/AlgoBuilder/IKS01A3
    ./IKS01A3/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Example/User/IKS01A2
    ../../Src/: algo_builder.c
    ./IKS01A2/Objects/: com.o cube_hal_l4.o demo_serial.o main.o nucleo_l476rg_bus.o sensor_commands.o serial_protocol.o stm32l4xx_it.o
  group Example/User/IKS01A3
    ../../Src/: algo_builder.c
    ./IKS01A3/Objects/: com.o cube_hal_l4.o demo_serial.o main.o nucleo_l476rg_bus.o sensor_commands.o serial_protocol.o stm32l4xx_it.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
target IKS01A3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: STM32L4xx-Nucleo-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\IKS01A3\Objects\@L.bin !L
  c flags: OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,USE_IKS01A3,ARM_MATH_CM4,USE_NUCLEO
  c misc: --C99
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\Drivers\BSP\Components\stts751;..\..\..\Drivers\BSP\IKS01A3;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
