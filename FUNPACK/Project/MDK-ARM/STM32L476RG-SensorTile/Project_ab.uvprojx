# Keil uVision project Project_ab.uvprojx, settings and files
target SensorTile-Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SensorTile-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\SensorTile-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_CM4,USE_SENSORTILE
  c misc: --no_conditionalize
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\Drivers\BSP\SensorTile;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ./SensorTile-Project/Objects/: hts221.o hts221_reg.o lps22hb.o lps22hb_reg.o lsm6dsm.o lsm6dsm_reg.o lsm303agr.o lsm303agr_reg.o
  group Drivers/BSP/SensorTile
    ./SensorTile-Project/Objects/: sensortile.o sensortile_env_sensors.o sensortile_env_sensors_ex.o sensortile_motion_sensors.o sensortile_motion_sensors_ex.o
  group Drivers/CMSIS
    ./SensorTile-Project/Objects/: system_stm32l4xx.o
  group Drivers/STM32L4xx_HAL_Driver
    ./SensorTile-Project/Objects/: stm32l4xx_hal.o stm32l4xx_hal_cortex.o stm32l4xx_hal_dma.o stm32l4xx_hal_gpio.o stm32l4xx_hal_i2c.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_ll_usb.o
  group Example/MDK-ARM
    ./SensorTile-Project/Objects/: startup_stm32l476xx.o
  group Example/AlgoBuilder
    ./SensorTile-Project/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/User
    ../../Src/: algo_builder.c
    ./SensorTile-Project/Objects/: cube_hal_l4.o demo_serial.o main.o sensortile_bus.o sensor_commands.o serial_protocol.o stm32l4xx_hal_msp.o stm32l4xx_it.o usbd_cdc_interface.o usbd_conf.o usbd_desc.o vcom.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Core
    ./SensorTile-Project/Objects/: usbd_core.o usbd_ctlreq.o usbd_ioreq.o
  group Middlewares/STM32_USBD_Library/Class/CDC
    ./SensorTile-Project/Objects/: usbd_cdc.o
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
