# IAR project Project.ewp, settings and files
configuration SensorTile-Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_USB_FS; USE_SENSORTILE; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\Drivers\BSP\SensorTile; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: SensorTile-Project.bin
  ILINK.IlinkOutputFile: SensorTile-Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../Drivers/BSP/Components/lsm6dsm/: lsm6dsm.c lsm6dsm_reg.c
  group Drivers/BSP/SensorTile
    ../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_env_sensors.c SensorTile_env_sensors_ex.c SensorTile_motion_sensors.c SensorTile_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Example/AlgoBuilder
    ../../Src/: ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../../Src/: algo_builder.c cube_hal_l4.c demo_serial.c main.c sensor_commands.c serial_protocol.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c vcom.c
    ../../../Drivers/BSP/SensorTile/: SensorTile_bus.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc32_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
